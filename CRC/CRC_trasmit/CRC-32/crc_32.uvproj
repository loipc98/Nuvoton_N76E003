# Keil uVision project crc_32.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: crc_32 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\Include;..\CRC-32
  group Source Group 1
    ./: crc_32.c
  group Common
    ../../../Common/: Common.c Delay.c
  group Startup
    ../../../Startup/: STARTUP.A51
